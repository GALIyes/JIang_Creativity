# Keil uVision project F103_VTCXO_Dockyard32_AC6.uvprojx, settings and files
target F103_VTCXO (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  cpu: CPUTYPE("Cortex-M3") ELITTLE
  output: F103_VTCXO +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER
  c misc: -mcpu=cortex-m3 -g -fshort-enums
  c include: SourceTree\Core\Inc;SourceTree\Drivers\STM32F1xx_HAL_Driver\Inc;SourceTree\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;SourceTree\Drivers\CMSIS\Device\ST\STM32F1xx\Include;SourceTree\Drivers\CMSIS\Include
  asm define: STM32F103xB,USE_HAL_DRIVER
  asm misc: -mcpu=cortex-m3
  asm include: as above
  memory RVCT4: ROM 0x08000000 size 0x00010000
  memory RVCT9: RAM 0x20000000 size 0x00005000
  scatter file: Generated\F103_VTCXO.sct
  link misc: --entry Reset_Handler --map --symbols
  group Core/Src
    SourceTree/Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c app_uart_debug.c app_dac8571.c app_console_cmd.c app_cpld_spi_maxv.c app_gps_uart.c app_gps_rmc.c app_gpsdo.c app_pps.c app_timebase.c app_gpsdo_dryrun.c app_tmp117.c app_vct_adc.c app_gpsdo10.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    SourceTree/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Generated Startup
    Generated/: startup_stm32f103xb_ac6.s
